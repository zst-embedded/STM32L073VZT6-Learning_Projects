# Keil uVision project FATFS-SD_Card.uvprojx, settings and files
target FATFS-SD_Card (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L073VZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: FATFS-SD_Card
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;../Drivers/BSP/STM32L073Z_EVAL;../Drivers/BSP/Components/Common;../Drivers/BSP/Components
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: spi.c user_diskio.c fatfs.c stm32l0xx_hal_msp.c stm32l0xx_it.c gpio.c main.c sd_diskio.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_cortex.c stm32l0xx_hal_spi.c stm32l0xx_hal_gpio.c stm32l0xx_hal_tim.c stm32l0xx_hal_flash_ex.c
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/BSP/STM32L073Z_EVAL
    ../Drivers/BSP/STM32L073Z_EVAL/: stm32l073z_eval.c stm32l073z_eval_eeprom.c stm32l073z_eval_idd.c stm32l073z_eval_io.c stm32l073z_eval_lcd.c stm32l073z_eval_sd.c
software components: CMSIS:CORE 5.0.2
